# Keil uVision project GAgent_v3.uvproj, settings and files
target GAgent_HFLPB100 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: GAgent_LPB100 +hex
  AfterMake: fromelf --bin --output ./../../../target/GAgent_LPB100_UART.bin ./output/GAgent_LPB100.axf
  AfterMake: ./LPB100_IMG_TOOLS/LPB100_IMG_Tools.exe ./../../../target/GAgent_LPB100_UART.bin ./../../../target/GAgent_LPB100_NETUPGRADE.bin
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: __KEIL_MDK__ __LPB100__ GAGENT_PROTOCOL_V3
  c misc: --diag_suppress=494  --c99
  c include: ..\product\sdk\1.40\include;..\product;..\..\..\gagent\include;..\..\..\gagent\cloud\inc;..\..\..\gagent\core\inc;..\..\..\gagent\lan\inc;..\..\..\gagent\local\inc;..\..\..\iof
  scatter file: LPBS2W.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr)
  group libs
    ../product/sdk/1.40/libs/: LPB100Kernel.lib
  group lpb100
    ../: gagent_hf_drv.c
    ../product/: app_main.c lpb100driver.c startup.c
  group main
    ../../../gagent/main/src/: gagent.c main.c
  group core
    ../../../gagent/core/src/: gagent_netevent.c user_misc.c utilcoding.c bufman.c
  group cloud
    ../../../gagent/cloud/src/: cloud.c http.c mqttbase.c mqttlib.c mqttxpg.c gagent_md5.c
  group lan
    ../../../gagent/lan/src/: lan.c lantcp.c lanudp.c webconfig.c 3rdlan.c
  group local
    ../../../gagent/local/src/: hal_receive.c local.c mcu_common.c local_v3.c local_common.c
